SRC_URI += "file://user_2018-01-28-18-00-00.cfg \
            file://user_2018-01-28-19-27-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

